## test/testcase.yaml
```yaml
tests:
  modules.npm6001:
    tags: npm6001
    platform_allow: nrf5340dk_nrf5340_cpuapp
    integration_platforms:
      - nrf5340dk_nrf5340_cpuapp
```
